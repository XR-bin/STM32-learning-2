# Keil uVision project test.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\sys;..\USER;..\STM32F4xx_StdPeriph_Driver\inc;..\HARDWARE\inc;..\SYSTEM\usart;..\SYSTEM\nvic;..\SYSTEM\exit;..\SYSTEM\delay;..\SYSTEM\time
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ../SYSTEM/sys/: system_stm32f4xx.c
    ./: startup_stm32f40_41xxx.s test.c
  group SYSTEM
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/nvic/: nvic.c
    ../SYSTEM/exit/: exit.c
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/time/: time.c
  group HARDWARE
    ../HARDWARE/src/: led.c beep.c key.c iic.c at24cxx.c lcd.c font.c spi.c w25q64.c touch.c adc.c pwm.c capture.c dma.c rtc.c fsmc.c iwdg.c can.c matrix.c OLED.c
  group STM32F4xx_StdPeriph_Driver
    ../STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group README
    ./ReadMe/: ReadMe.txt
